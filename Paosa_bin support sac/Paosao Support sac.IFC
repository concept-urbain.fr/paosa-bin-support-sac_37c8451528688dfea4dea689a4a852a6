Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Paosao Support sac.IFC
Time: 2020-07-01T12:02:12
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: PAO-COR-SUP-STRUC-MUL-V2-002_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 23.4028; Area Measure: 2.53882; Volume Measure: 0.00530237
